## prj.conf
```kconfig
CONFIG_STDOUT_CONSOLE=y
CONFIG_GPIO=y
CONFIG_ARC_INIT=y
CONFIG_SERIAL=y
```

## src/main.c
```c
#include <zephyr.h>

void main (void)
{
	while(1)
	{
		task_yield();
	}
}
```
